# Keil uVision project test.uvprojx, settings and files
target Target 1 (6220000::V6.22::ARMCLANG)
  device: STM32F091RCTx STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.1.1
  cpu: IRAM(0x20000000,0x00008000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: test
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=3
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group Headers
    ../NucleoTemplate/: ad.h buttons.h leds.h usart2.h
  group Sources
    ./: main.c
    ../NucleoTemplate/: ad.c buttons.c leds.c usart2.c
software components: CMSIS:CORE 6.1.0, Device:Startup 1.0.0
